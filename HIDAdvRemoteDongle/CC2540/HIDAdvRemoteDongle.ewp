# IAR project HIDAdvRemoteDongle.ewp, settings and files
configuration CC2540USB HID AdvRemoteDongle (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xPOWER_SAVING; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; HAL_KEY=FALSE; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_HID=TRUE; USB_SETUP_MAX_NUMBER_OF_INTERFACES=3; HCI_DISABLE_UART; NANO_DONGLE; HAL_UART=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\common; ..\Source; ..\include; ..\Components\hal\include; ..\Components\hal\target\CC2540USB; ..\Components\hal\target\CC2540USB\usb\library; ..\Components\hal\target\CC2540USB\usb\library\cc2540_hid; ..\Components\hal\target\CC2540USB\usb\library\usb_hid; ..\Components\hal\target\CC2540USB\usb\class_hid; ..\Components\osal\include; ..\Components\services\saddr; ..\Components\ble\include; ..\Components\ble\controller\CC254x\phy; ..\Components\ble\controller\CC254x\include; ..\Components\ble\hci; ..\Components\ble\host; ..\Components\ble\ROM; ..\common\cc2540; ..\Profiles\Roles\CC254x; ..\Profiles\Roles; ..\Profiles\KeyboardDongleProfile\CC254x; ..\Profiles\KeyboardDongleProfile; ..\Profiles\DevInfo; ..\Profiles\HIDDev\CC254x
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: hidapp.c hidapp.h Hidapp_Main.c keyboardMap.h OSAL_Hidapp.c
  group HAL/Common
    ../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540USB/Config
    ../Components/hal/target/CC2540USB/: hal_board_cfg.h
  group HAL/Target/CC2540USB/Drivers
    ../Components/hal/target/CC2540USB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540USB/Includes
    ../Components/hal/target/CC2540USB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540USB/USB/class_hid
    ../Components/hal/target/CC2540USB/usb/class_hid/: usb_class_requests.c usb_class_requests.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h usb_hid.c usb_hid.h usb_hid_descriptor.s51 usb_hid_hooks.c usb_hid_reports.c usb_hid_reports.h
  group HAL/Target/CC2540USB/USB/library
    ../Components/hal/target/CC2540USB/usb/library/: usb_descriptor.h usb_framework.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2540USB/USB/library/cc2540_hid
    ../Components/hal/target/CC2540USB/usb/library/cc2540_hid/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group HAL/Target/CC2540USB/USB/library/usb_hid
    ../Components/hal/target/CC2540USB/usb/library/usb_hid/: usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework_structs.h usb_interrupt.h
  group INCLUDE
    ../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../Components/ble/host/: linkdb.h
    ../Components/ble/controller/CC254x/include/: ll.h ll_sleep.h phy.h
  group LIB
    ../Libraries/CC2540DB/bin/: CC2540_BLE.lib
    ../Libraries/Common/bin/: CC254x_BLE_HCI_TL_Full.lib CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../Components/ble/include/: bcomdef.h
    ../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../Include/: gapgattserver.h gattservapp.h
    ../Components/ble/host/: gatt_uuid.c
    ../Profiles/GATT/: gattservapp_util.c
    ../Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../Profiles/KeyboardDongleProfile/CC254x/: keyboardDongleProfile.c
    ../Profiles/KeyboardDongleProfile/: keyboardDongleProfile.h
  group TOOLS
    ../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../common/cc2540/: lnk51ew_cc2530b_banked_rom_data.xcl lnk_banked_rom_data.xcl OnBoard.c OnBoard.h
